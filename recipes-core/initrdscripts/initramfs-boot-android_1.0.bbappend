FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_bass = "bass"
COMPATIBLE_MACHINE_nemo = "nemo"
